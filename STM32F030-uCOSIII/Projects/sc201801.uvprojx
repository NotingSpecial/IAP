# Keil uVision project sc201801.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sc201801 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\User\BSP;..\User\Main;..\UCOS_III\uC-CPU\cfg;..\UCOS_III\uCOS-III\cfg;..\UCOS_III\uCOS-III\Ports;..\UCOS_III\uCOS-III\Source;..\UCOS_III\uC-CPU;..\UCOS_III\uC-LIB;..\UCOS_III\uC-CPU\Port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/CMSIS/Device/Source/: system_stm32f0xx.c startup_stm32f030.s
  group USER
    ../User/Main/: main.c stm32f0xx_it.c includes.h
  group BSP
    ../User/BSP/: bsp.c bsp_usart.c bsp_RS485.c bsp_i2c.c bsp_led.c
  group Drivers
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
